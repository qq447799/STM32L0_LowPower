# Keil uVision project L071LowPower.uvprojx, settings and files
target PM (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32L071KBUx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: L071Lowpower +hex
  AfterMake: D:\tools_keil\install\ARM\ARMCC\bin\fromelf.exe  --bin -o  ./OUTPUT/@L.bin  ./OUTPUT/@L.axf
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER  STM32L071xx
  c include: .\CFG;.\CMSIS;.\Lib;.\Start_Code;.\Bsp;.\Main
  asm define: STM32L071xx USE_FULL_LL_DRIVER
  asm include: .\Start_Code;.\Lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start_Code
    ./Start_Code/: startup_stm32l071xx.s
  group CMSIS
    ./CMSIS/: stm32l0xx.h stm32l071xx.h system_stm32l0xx.c system_stm32l0xx.h
    ./Lib/: stm32l0xx_hal_cortex.c stm32l0xx_hal_cortex.h
  group Lib
    ./Lib/: stm32l0xx_hal_gpio.h stm32l0xx_hal_gpio.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc.h stm32l0xx_ll_gpio.c stm32l0xx_ll_gpio.h stm32l0xx_hal.c stm32l0xx_hal.h stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c stm32l0xx_ll_usart.c stm32l0xx_ll_lpuart.c stm32l0xx_hal_tim.c stm32l0xx_hal_lptim.c stm32l0xx_ll_tim.c stm32l0xx_ll_rcc.c stm32l0xx_ll_lptim.c stm32l0xx_hal_dma.c stm32l0xx_ll_dma.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rcc_ex.h stm32l0xx_hal_uart_ex.h stm32l0xx_hal_usart_ex.h stm32l0xx_ll_exti.c stm32l0xx_ll_exti.h stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_pwr.h stm32l0xx_hal_pwr_ex.h stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_adc.h stm32l0xx_hal_adc_ex.h
  group Bsp
    ./Bsp/: Bsp_Timer.h Bsp_Timer.c Bsp_LedCtrl.c Bsp_LedCtrl.h Bsp_Uart.c Bsp_Uart.h Bsp_Gpio.c Bsp_Gpio.h
  group CFG
    ./CFG/: include.h stm32l0xx_hal_conf.h
    ./Lib/: stm32l0xx_hal_def.h
  group Main
    ./Main/: Main.c Main.h stm32l0xx_it.c stm32l0xx_it.h
  group DOC
    ./Doc/: Rev.txt
